# IAR project FreeRTOS_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPC2000_IAR
  ICCARM.CCIncludePath2: E:\Setup\FreeRTOS\FreeRTOSv202112.00\FreeRTOS\Source\include; E:\Setup\FreeRTOS\FreeRTOSv202112.00\FreeRTOS\Source\portable\IAR\LPC2000; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: E:\Setup\FreeRTOS\FreeRTOSv202112.00\FreeRTOS\Source\include; E:\Setup\FreeRTOS\FreeRTOSv202112.00\FreeRTOS\Source\portable\IAR\LPC2000; E:\Setup\FreeRTOS\FreeRTOSv202112.00\FreeRTOS\Demo\Common\include; $PROJ_DIR$; D:\MyPrograms\Embedded Test\Keil Arm\IARARM\Aditya
  OBJCOPY.OOCOutputFile: FreeRTOS_Test.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\linker\NXP\LPC2148.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    E:/Setup/FreeRTOS/FreeRTOSv202112.00/FreeRTOS/Source/portable/MemMang/: heap_2.c
    E:/Setup/FreeRTOS/FreeRTOSv202112.00/FreeRTOS/Source/: list.c queue.c tasks.c
    ./: lpc2xxx_cstartup.s main.c
    E:/Setup/FreeRTOS/FreeRTOSv202112.00/FreeRTOS/Source/portable/IAR/LPC2000/: port.c portasm.s79
